# Keil uVision project project.uvprojx, settings and files
target rtthread-stm32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: .;..\..\include;applications;.;drivers;Libraries\STM32F10x_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\components\CMSIS\Include;packages\at_device-latest;packages\pahomqtt-latest\MQTTPacket\src;packages\pahomqtt-latest\MQTTClient-RT;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\net\at\include;..\..\components\net\at\at_socket;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c startup.c canapp.c
  group Drivers
    drivers/: board.c stm32f10x_it.c led.c usart.c gpio.c bxcan.c sdcard.c
    ./drivers/: rt_spi_flash_device.c rt_stm32f10x_spi.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
    Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_rcc.c stm32f10x_wwdg.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_bkp.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_rtc.c stm32f10x_fsmc.c stm32f10x_tim.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_flash.c stm32f10x_sdio.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_can.c stm32f10x_cec.c misc.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group at_device
    packages/at_device-latest/: at_socket_ec20.c
    ./packages/at_device-latest/: at_socket_sim7600ce.c
  group paho-mqtt
    packages/pahomqtt-latest/MQTTPacket/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    packages/pahomqtt-latest/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt-latest/samples/: mqtt_sample.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../components/drivers/can/: can.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
  group AT
    ../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../components/net/at/at_socket/: at_socket.c
  group SAL
    ../../components/net/sal_socket/src/: sal_ipaddr.c sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_at.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
